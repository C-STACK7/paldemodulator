options:
  parameters:
    generate_options: qt_gui
    id: test_water
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: band
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: digital_gain
  id: variable
  parameters:
    value: '0.8'
  states: {}
- name: freq
  id: variable
  parameters:
    value: gfreq+1250000
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: gfreq
  id: variable_qtgui_range
  parameters:
    start: '5800000000'
    step: '1000000'
    stop: '6000000000'
    value: '5865000000'
    widget: counter
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '70.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: samples_per_line * 60 * .999 * 525 / 2
  states: {}
- name: samples_per_line
  id: variable
  parameters:
    value: '768'
  states: {}
- name: analog_pll_freqdet_cf_1
  id: analog_pll_freqdet_cf
  parameters:
    max_freq: '0.5'
    min_freq: '0.1'
    w: '1000000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: analog_quadrature_demod_cf_1
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '0.1'
    freq: '4500000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_reject_filter_1
  id: band_reject_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 2475000 + 1725000
    low_cutoff_freq: '-2475000 + 1725000'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '500000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_interleaved_char_0
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '1.0'
    vector_output: 'False'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '700'
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '1'
    vlen: '1'
  states: {}
- name: blocks_float_to_uchar_0_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '1'
    vlen: '1'
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: '1200000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: ccf
    width: '50000'
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    ant0: RX1
    bb_gain0: '20'
    bw0: band
    freq0: freq
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: video_sdl_sink_0
  id: video_sdl_sink
  parameters:
    display_height: '480'
    display_width: '640'
    fps: '0'
    height: '480'
    num_channels: '3'
    type: byte
    width: '640'
  states: {}

connections:
- [analog_pll_freqdet_cf_1, '0', blocks_add_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', blocks_float_to_uchar_0, '0']
- [analog_quadrature_demod_cf_1, '0', blocks_float_to_uchar_0_0, '0']
- [analog_sig_source_x_1, '0', blocks_add_xx_0, '1']
- [band_reject_filter_1, '0', blocks_complex_to_interleaved_char_0, '0']
- [band_reject_filter_1, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_add_xx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_interleaved_char_0, '0', video_sdl_sink_0, '0']
- [blocks_delay_0, '0', band_reject_filter_1, '0']
- [blocks_float_to_complex_0, '0', analog_quadrature_demod_cf_1, '0']
- [blocks_float_to_uchar_0, '0', video_sdl_sink_0, '1']
- [blocks_float_to_uchar_0_0, '0', video_sdl_sink_0, '2']
- [filter_fft_low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [osmosdr_source_0, '0', analog_pll_freqdet_cf_1, '0']
- [osmosdr_source_0, '0', blocks_delay_0, '0']
- [osmosdr_source_0, '0', filter_fft_low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
